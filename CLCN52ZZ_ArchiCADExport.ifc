Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2021-05-11T09:57:50
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (3)
Pset_DistributionPortPipe - ConnectionType: WELDED
MEPPortPipe - ProfileShape: ROUND
Name | FlowDirection | PortNumber | OuterDiameter (mm) = ConnectorDiameter (mm) = NominalWidth (mm) = NominalHeight (mm)
 | SINK | 1 | 15
 | SINK | 2 | 15
 | SOURCE | 3 | 50

# IfcEnergyConversionDevice: Repelo Conceal Cistern - Asia, CLCN52ZZ:Repelo Conceal Cistern - Asia:3480
In: Level 1
Pset_ManufacturerTypeInformation - ModelReference: Repelo Conceal Cistern - Asia; Manufacturer: American Standard; ProductionYear: 2021
Pset_DistributionFlowElementCommon - Reference: Repelo Conceal Cistern - Asia
Constraints - Elevation: 0 mm
Dimensions - Area: 0.420961 m2; Volume: 0.0214473 m3
Identity Data - Mark: 1
Mechanical - System Classification: Domestic Cold Water
Other - AssetIdentifier: n/a; BarCode: Please Record On Commissioning.; Category: Plumbing Fixtures; Family: CLCN52ZZ: Repelo Conceal Cistern - Asia; Family and Type: CLCN52ZZ: Repelo Conceal Cistern - Asia; InstallationDate: Please Record On Commissioning.; SerialNumber: Please Record On Commissioning.; Type: CLCN52ZZ: Repelo Conceal Cistern - Asia; Type Id: CLCN52ZZ: Repelo Conceal Cistern - Asia; WarrantyStartDate: Please Record On Commissioning.
Phasing - Phase Created: New Construction
Constraints(Type) - Default Elevation: 0 mm
Data(Type) - ConnectionSize: n/a; FlowRate: n/a; InstallationType: n/a; ProductCategory: Pro & Commercial (70); ProductGroup: Conceal cistern (01); ProductWeight: n/a; StyleSegment: n/a; SubCategory: Sanitary Systems (15)
Identity Data(Type) - Assembly Code: C1030200; Description: Repelo Conceal Cistern - Asia; Keynote: N13; Manufacturer: American Standard; Model: Repelo Conceal Cistern - Asia; OmniClass Number: 23.45.05.14.14; OmniClass Title: Sinks/Lavatories; Type Comments: CLCN52ZZ; Type Name: Repelo Conceal Cistern - Asia; URL: https://www.americanstandard-apac.com/
Model Properties(Type) - _Author: JY; _AuthorizedBy: bimstore; _BimSpecGuid: 0; _BSBibleVersion: 16; _CreatedBy: https://www.bimstore.co; _CurrentRevision: 1; _DistributedBy: https://www.bimstore.co; _ObjectUserGuide: https://www.bimstore.co/products/clcn52zz/document/object-user-guide; BIMObjectName: AmericanStandard_ConcealCistern_Repelo_(CLCN52ZZ); NBSDescription: WC cisterns; NBSNote: n/a; NBSObjectName: American Standard - WC cisterns; NBSOfficeMasterTag: n/a; NBSReference: 45-35-70/383
Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; ClassificationName: Uniclass2015; ClassificationValue: Pr_40_20_93_89; CodePerformance: n/a; Color: n/a; Constituents: n/a; CreatedBy: https://www.americanstandard-apac.com/; CreatedOn: 2021-03-01T09:00:00; DocumentationCertificates: https://www.bimstore.co/products/clcn52zz/document/product-certificates; DocumentationInstallationGuide: https://www.bimstore.co/products/clcn52zz/document/installation-guide; DocumentationLiterature: https://www.bimstore.co/products/clcn52zz/document/product-literature; DocumentationMaintenance: https://www.bimstore.co/products/clcn52zz/document/maintenance-information; DocumentationTechnical: https://www.bimstore.co/products/clcn52zz/document/technical-data-sheet; DurationUnit: Years; ExpectedLife: 0; Family Name: CLCN52ZZ; Features: n/a; Finish: n/a; Grade: n/a; ManufacturerName: American Standard; Material: n/a; ModelNumber: CLCN52ZZ; ModelReference: Repelo Conceal Cistern - Asia; ProductionYear: 2021; ReferencedStandard: n/a; ReplacementCost: n/a; Shape: n/a; Size: n/a; TypeName: Repelo Conceal Cistern - Asia; WarrantyDescription: n/a; WarrantyDurationLabor: 0; WarrantyDurationParts: 0; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.americanstandard-apac.com/; WarrantyGuarantorParts: https://www.americanstandard-apac.com/
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
